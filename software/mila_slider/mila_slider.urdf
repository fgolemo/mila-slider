Commit message: init with slider code

File: software/mila_slider/mila_slider.urdf (robot description, URDF)
Before this commit: robot PoppyErgoJr, 4 links, 3 joints
Links:
- removed link section_2
Joints:
- removed joint m3
